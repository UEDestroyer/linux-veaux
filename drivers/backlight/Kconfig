## drivers/soc/qcom/veaux/Kconfig.bak
```kconfig
menu "Xiaomi Veux support"

config VEAUX_RPMH
    bool "Veux RPMH support"
    depends on ARCH_QCOM
    default n

endmenu
```
